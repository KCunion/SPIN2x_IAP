# IAR project SPIN2XPWMDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN27PF MM32SPIN27PF
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_IAR; USE_STDPERIPH_DEVICE
  ICCARM.CCIncludePath2: ..\MM32SPIN2xx_p_LIB\Include; E:\桌面\SPIN27Demo\PWM\MM32SPIN2xx_p_LIB\HAL_lib\inc; ..\SYSTEM; ..\HARDWARE\HALL; ..\HARDWARE\LED; ..\HARDWARE\PWM; ..\HARDWARE\TIM1
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPIN2XPWMDemo.srec
  ILINK.IlinkOutputFile: SPIN2XPWMDemo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HAL_Lib
    ../MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HARDWARE
    ../HARDWARE/HALL/: hall.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/TIM1/: tim1.c
  group README
    ../: README.TXT
  group StartUp
    ../MM32SPIN2xx_p_LIB/Source/IAR_StartAsm/: startup_MM32SPIN2xx_p.s
    ../MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c uart.c
  group USER
    ../USER/: main.c
