# Keil uVision project MM32SPIN2xxDemo.uvprojx, settings and files
target SPIN27Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32SPIN27PF MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SPIN27Demo +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/SPIN27Demo.bin ./Objects/SPIN27Demo.axf
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\MM32SPIN2xx_p_LIB\HAL_lib\inc;..\MM32SPIN2xx_p_LIB\Include;..\CMSIS\KEIL_CORE;..\HARDWARE\inc;..\SYSTEM\inc
  memory RVCT4: ROM 0x8010000 size 0x10000
  memory RVCT9: RAM 0x20000600 size 0x1a00
  group Startup
    ../MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.c
    ../MM32SPIN2xx_p_LIB/Source/KEIL_StartAsm/: startup_MM32SPIN2xx_p.s
  group HAL_Lib
    ../MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HARDWARE
    ../HARDWARE/: led.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c
  group USER
    ../USER/: main.c
  group README
    ../: README.TXT
